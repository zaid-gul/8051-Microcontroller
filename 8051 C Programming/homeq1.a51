ORG 0000H
	CLR A
	HERE:
	CALL CHECK
	JMP HERE
CHECK:
	CJNE A,#255,COUNTING
	MOV P1,A
	MOV P2,A
	MOV P3,A
	MOV P0,A
	COUNTING:
	MOV P1,A
	MOV P2,A
	MOV P3,A
	MOV P0,A
	INC A
	CALL DELAY
	RET
DELAY:
	MOV TMOD,#01H
	MOV TH0,#0FEH
	MOV TL0,#0CH
	SETB TR0
	JNB TF0,$
	CLR TF0
	CLR TR0
	RET	
	END
