# Keil uVision project 8051 PROJECT.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8051 PROJECT +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: project 8051.a51 project 8051 (sample).a51
