ORG 00H
MOV A,#38H
ACALL CMD
MOV A,#0EH
ACALL CMD
MOV A,#01H
ACALL CMD
MOV A,#06H
ACALL CMD
MOV A,#0EH
ACALL CMD
MOV A ,#82H
ACALL CMD
MOV A,#'H'
ACALL DATA
ACALL DELAY
MOV A ,#83H
ACALL CMD
MOV A,#'E'
ACALL DATA
ACALL DELAY
MOV A ,#84H
ACALL CMD
MOV A,#'L'
ACALL DATA
ACALL DELAY
MOV A ,#85H
ACALL CMD
MOV A,#'L'
ACALL DATA
ACALL DELAY
MOV A ,#86H
ACALL CMD
MOV A,#'O'
ACALL DATA
ACALL DELAY
MOV A ,#0C5H
ACALL CMD
MOV A,#'U'
ACALL DATA
ACALL DELAY
MOV A ,#0C6H
ACALL CMD
MOV A,#'E'
ACALL DATA
ACALL DELAY
MOV A ,#0C7H
ACALL CMD
MOV A,#'T'
ACALL DATA
ACALL DELAY
CMD:
MOV P1,A
MOV P2.0,#0
MOV P2.1,#0
MOV P2.2,#1
ACALL DELAY
MOV P2.2,#0
RET
DATA:
MOV P1,A
MOV P2.0,#1
MOV P2.1,#0
MOV P2.2,#1
ACALL DELAY
MOV P2.2,#0
RET
DELAY: MOV R4,#05H ; subroutine for delay 1/2 sec
WAIT1: MOV R3,#00H
WAIT2: MOV R2,#00H
WAIT3: DJNZ R2,WAIT3     ; decrement and jump if not zero     (255 times)
DJNZ R3,WAIT2             ; decrement and jump if not zero 
DJNZ R4,WAIT1         ; decrement and jump if not zero 
RET  
END

